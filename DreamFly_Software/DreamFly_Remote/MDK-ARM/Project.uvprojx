# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS;..\Drivers\STM32F10x_StdPeriph_Driver\Inc;..\Drivers\STM32F10x_StdPeriph_Driver\Src;..\Core\Inc;..\Core\Src;..\System;..\BSP\Power;..\BSP\JoyStick;..\BSP\LED;..\BSP\WS2812B;..\BSP\Key;..\BSP\Buzzer;..\BSP\OLED;..\BSP\nRF24L01;..\Common;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f10x_md.s
  group Applicatiom/User/Core
    ../Core/Src/: main.c NVIC.c GPIO.c USART.c TIM.c ADC.c I2C.c SPI.c Flash.c stm32f10x_it.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group System
    ../System/: Delay.c STM32F103C8T6.c
  group BSP
    ../BSP/JoyStick/: JoyStick.c
    ../BSP/LED/: LED.c
    ../BSP/WS2812B/: WS2812B.c
    ../BSP/Buzzer/: Buzzer.c
    ../BSP/Key/: Key.c
    ../BSP/OLED/: OLED.c OLEDFont.c
    ../BSP/nRF24L01/: nRF24L01P.c
  group Common
    ../Common/: Filter.c
  group APP
    ../APP/: Scheduler.c Remote.c
