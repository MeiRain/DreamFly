# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS;..\Drivers\STM32F4xx_StdPeriph_Driver\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\Src;..\Core\Inc;..\Core\Src;..\API\VL53L1\Core;..\API\VL53L1\Platform;..\System;..\BSP\LED;..\BSP\WS2812B;..\BSP\Motor;..\BSP\ICM20948;..\BSP\AK09916;..\BSP\BMP280;..\BSP\Si24R1;..\BSP\VL53L1X;..\BSP\PWM3901MB;..\Common;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c NVIC.c USART.c TIM.c ADC.c IIC.c I2C.c SPI.c FLASH.c stm32f4xx_it.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/Src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c
  group API
    ../API/VL53L1/Core/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../API/VL53L1/Platform/: vl53l1_platform.c
  group System
    ../System/: Delay.c Delay.h STM32F411CEU6.c STM32F411CEU6.h
  group BSP
    ../BSP/LED/: LED.c
    ../BSP/WS2812B/: WS2812B.c
    ../BSP/Motor/: Motor.c
    ../BSP/ICM20948/: ICM20948.c
    ../BSP/Si24R1/: Si24R1.c
    ../BSP/AK09916/: AK09916.c
    ../BSP/BMP280/: BMP280.c
    ../BSP/VL53L1X/: VL53L1X.c
    ../BSP/PWM3901MB/: PMW3901MB.c
  group Common
    ../Common/: Filter.c Attitude.c Altitude.c PID.c ANOAssistant.c Position.c Position.h
  group APP
    ../APP/: Scheduler.c Flight.c
